# Keil uVision project sw_FP&WIFI.uvproj, settings and files
target 指纹WIFI开关 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: file_download +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Usr;.\Usr_lib;.\Sensor;.\Actuator;.\data_Trans;.\std_Lib
  link misc: REMOVEUNUSED
  group 用户文件
    ./Usr/: User_main.c dataManage.c appTimer.c Tips.c
  group 传感器
    ./Sensor/: usrKin.c HYM8564.c sensor_FP.c
  group 执行器
    ./Actuator/: Relay.c timerAct.c
  group 数据传输
    ./data_Trans/: dataTrans.c wifi_LPT220.c
  group 外设库
    ./std_Lib/: delay.c EEPROM.c Soft_UART.c GPIO.c USART.C timer.c
  group 解析方法库_自定义扩展
    ./Usr_lib/: pars_Method.c
